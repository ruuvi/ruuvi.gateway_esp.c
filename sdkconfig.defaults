## sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_UNICORE=y
CONFIG_ETH_RMII_CLK_OUTPUT=n
CONFIG_ETH_RMII_CLK_INPUT=y
CONFIG_ETH_RMII_CLK_IN_GPIO=0
```
